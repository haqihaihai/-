# Keil uVision project STM32F405-MEIC.uvprojx, settings and files
target MEIC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405-MEIC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\LIB\inc;..\MEIC_BSP\inc;..\MEIC_DRIVER\inc;..\MEIC_TASK\inc;..\MEIC_SYSTEM\RT-Thread_finsh;..\MEIC_SYSTEM\RT-Thread_include;..\MEIC_SYSTEM\RT-Thread_ports;..\MEIC_SYSTEM\RT-Thread_source;..\MEIC_SYSTEM\RT-Thread_include\libc;..\MEIC_USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../MEIC_USER/: main.c stm32f4xx_it.c board.c rtconfig.h
  group BSP
    ../MEIC_BSP/src/: BSP_All.c
    ../MEIC_BSP/inc/: Include.h
  group Driver
    ../LIB/src/: stm32f4xx_iwdg.c
    ../MEIC_DRIVER/src/: Driver_USART.c delay.c DRIVER_DBUS.c driver_Laser_plate.c timer.c usart_go.c mathematicalmadel.c GO-M8010-6.c foot_trajectory.c DMA.c force_control.c
  group Task
    ../MEIC_TASK/src/: app_thread.c control.c
  group Core
    ../CORE/startup/: startup_stm32f40_41xxx.s
    ../CORE/: system_stm32f4xx.c arm_cortexM4lf_math.lib
  group Std_Lib
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group RT-Thread_source
    ../MEIC_SYSTEM/RT-Thread_source/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../MEIC_SYSTEM/RT-Thread_finsh/: cmd.c msh.c shell.c
  group RT-Thread_ports
    ../MEIC_SYSTEM/RT-Thread_ports/: cpuport.c context_rvds.S
